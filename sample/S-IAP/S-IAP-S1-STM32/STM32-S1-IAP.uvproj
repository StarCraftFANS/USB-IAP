# Keil uVision project STM32-S1-IAP.uvproj, settings and files
target LED-DEMO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: S1-IAP +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\USER;..\..\..\app\display;..\..\..\app\FWlib_ST\inc;..\..\..\app\iap\boot;..\..\..\app\pwm_st;..\..\..\app\CMSIS_ST
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../../../app/CMSIS_ST/startup/: startup_stm32f10x_md.s
  group USER
    ./USER/: main.c stm32f10x_it.c SysTick.c
  group boot
    ../../../app/iap/boot/: boot1.c fifo.c flash.c
  group pwm
    ../../../app/pwm_st/: Pwm_T1.c Pwm_T2.c Pwm_T3.c Pwm_T4.c
  group display
    ../../../app/display/: 12864i_012.c Font.c
  group FWlib
    ../../../app/FWlib_ST/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../../../app/CMSIS_ST/: core_cm3.c system_stm32f10x.c
