# Keil uVision project M0518.uvproj, settings and files
target APROM_code (ARM-ADS)
  device: M0518LD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: S-APP +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: .\User;..\..\..\app\Library_M0\StdDriver\inc;..\..\..\app\Library_M0\CMSIS\Include;..\..\..\app\iap\boot;..\..\..\app\pwm_m0;..\..\..\app\display;..\..\..\app\Library_M0\Device\Nuvoton\M0518\Include;..\..\..\app\Library_M0\Device\Nuvoton\M0518\Source\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x3000 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../app/Library_M0/Device/Nuvoton/M0518/Source/: system_M0518.c
    ../../../app/Library_M0/Device/Nuvoton/M0518/Source/ARM/: startup_M0518.s
  group User
    ./User/: main.c
  group boot
    ../../../app/iap/boot/: boot1.c fifo.c flash.c
  group pwm
    ../../../app/pwm_m0/: ledpwm.c
  group display
    ../../../app/display/: oled.c Font.c
  group Library
    ../../../app/Library_M0/StdDriver/src/: adc.c bpwm.c clk.c gpio.c pwm.c retarget.c sys.c timer.c uart.c wdt.c fmc.c
